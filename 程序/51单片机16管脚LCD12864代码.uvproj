# Keil uVision project 51单片机16管脚LCD12864代码.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 简易示波器 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP\st7565;.\APP\osc_scope;.\APP\TLC0820
  group Source Group 1
    ./: main.c
    ./APP/st7565/: st7565.c
    ./APP/osc_scope/: osc_scope.c
    ./APP/TLC0820/: TLC0820.c
